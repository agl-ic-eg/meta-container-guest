
IMAGE_INSTALL_append = " \
     can-utils iproute2 \
     "

